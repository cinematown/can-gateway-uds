<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f429zi_uds.ewp</path>
  </project>
  <batchBuild />
</workspace>
